# Keil uVision project ble_app_hrs_s110_with_dfu_pca10028.uvprojx, settings and files
target nrf51422_xxac_s110 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: nRF51422_xxAC Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.5.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(16000000) ELITTLE
  output: nrf51422_xxac_s110 +hex
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1
  c define: BLE_DFU_APP_SUPPORT BLE_STACK_SUPPORT_REQD S110 BOARD_PCA10028 SOFTDEVICE_PRESENT NRF51
  c misc: --c99
  library: MicroLIB
  memory RVCT4: ROM 0x18000 size 0x28000
  memory RVCT9: RAM 0x20002000 size 0x6000
  group Application
    ../../../: main.c bta_ble.c bta_ble.h nrf_uart.c
  group Documentation
    ../../../: Abstract.txt license.txt todo.txt
target flash_softdevice (ARM-ADS)
  device: nRF51422_xxAC Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.5.0
  cpu: as above
  output: s110_softdevice.hex +hex
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1
  c define: BLE_STACK_SUPPORT_REQD
  c misc: --c99
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
software components: CMSIS:CORE 4.3.0, Board Support:bsp 11.0.0-2.alpha, Board Support:bsp 8.0.0, Device:Startup 8.5.0, nRF_BLE:BLE_Modules:ble_advdata 2.0.0, nRF_BLE:BLE_Modules:ble_advdata 4.0.0-2.alpha, nRF_BLE:BLE_Modules:ble_advertising 2.0.0, nRF_BLE:BLE_Modules:ble_advertising 4.0.0-2.alpha, nRF_BLE:BLE_Modules:ble_common 2.0.0, nRF_BLE:BLE_Modules:ble_common 4.0.0-2.alpha, nRF_BLE:BLE_Modules:ble_conn_params 2.0.0, nRF_BLE:BLE_Modules:ble_conn_params 4.0.0-2.alpha, nRF_BLE:BLE_Modules:ble_service_common 2.0.0, nRF_BLE:BLE_Modules:ble_service_common 4.0.0-2.alpha, nRF_BLE:BLE_Modules:device_manager 2.0.0, nRF_BLE:BLE_Modules:device_manager 4.0.0-2.alpha, nRF_BLE:BLE_Services:ble_bas 4.0.0-2.alpha, nRF_BLE:BLE_Services:ble_dfu 2.0.0, nRF_BLE:BLE_Services:ble_dfu 4.0.0-2.alpha, nRF_BLE:BLE_Services:ble_dis 4.0.0-2.alpha, nRF_BLE:BLE_Services:ble_hrs 4.0.0-2.alpha, nRF_BLE:BLE_Services:ble_nus 2.0.0, nRF_BLE:BLE_Services:ble_nus 4.0.0-2.alpha, nRF_Drivers:app_uart 2.0.0, nRF_Drivers:app_uart 4.0.0-2.alpha, nRF_Drivers:nrf_delay 2.0.0, nRF_Drivers:nrf_delay 4.0.0-2.alpha, nRF_Drivers:nrf_error 2.0.0, nRF_Drivers:nrf_error 4.0.0-2.alpha, nRF_Drivers:nrf_gpio 2.0.0, nRF_Drivers:nrf_gpio 4.0.0-2.alpha, nRF_Drivers:pstorage 2.0.0, nRF_Drivers:pstorage 4.0.0-2.alpha, nRF_Libraries:DFU:dfu_app_handler 2.0.0, nRF_Libraries:DFU:dfu_app_handler 4.0.0-2.alpha, nRF_Libraries:DFU:dfu_bootloader_util 2.0.0, nRF_Libraries:DFU:dfu_bootloader_util 4.0.0-2.alpha, nRF_Libraries:app_button 2.0.0, nRF_Libraries:app_button 4.0.0-2.alpha, nRF_Libraries:app_error 2.0.0, nRF_Libraries:app_error 4.0.0-2.alpha, nRF_Libraries:app_fifo 2.0.0, nRF_Libraries:app_fifo 4.0.0-2.alpha, nRF_Libraries:app_gpiote 2.0.0, nRF_Libraries:app_gpiote 4.0.0-2.alpha, nRF_Libraries:app_timer 2.0.0, nRF_Libraries:app_timer 4.0.0-2.alpha, nRF_Libraries:app_trace 2.0.0, nRF_Libraries:app_trace 4.0.0-2.alpha, nRF_Libraries:app_util 2.0.0, nRF_Libraries:app_util 4.0.0-2.alpha, nRF_Libraries:nrf_assert 2.0.0, nRF_Libraries:nrf_assert 4.0.0-2.alpha, nRF_Libraries:retarget 2.0.0, nRF_Libraries:retarget 4.0.0-2.alpha, nRF_Libraries:sensorsim 2.0.0, nRF_Libraries:sensorsim 4.0.0-2.alpha, nRF_SoftDevice:Internal:sd_common 1.1.2, nRF_SoftDevice:Internal:sd_common 2.0.0-2.alpha, nRF_SoftDevice:Internal:softdevice_present 1.1.2, nRF_SoftDevice:Internal:softdevice_present 2.0.0-2.alpha, nRF_SoftDevice:s110 8.0.0, nRF_SoftDevice:s110 8.0.3, nRF_SoftDevice:s110_hex 8.0.0, nRF_SoftDevice:s110_hex 8.0.3, nRF_SoftDevice:softdevice_hex 1.1.2, nRF_SoftDevice:softdevice_hex 1.1.2
